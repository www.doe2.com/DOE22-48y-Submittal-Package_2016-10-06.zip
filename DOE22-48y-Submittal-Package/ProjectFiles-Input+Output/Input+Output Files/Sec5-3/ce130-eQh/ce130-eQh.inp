INPUT ..


$ ---------------------------------------------------------
$              Abort, Diagnostics
$ ---------------------------------------------------------




$ ---------------------------------------------------------
$              Global Parameters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Title, Run Periods, Design Days, Holidays
$ ---------------------------------------------------------

TITLE           
   LINE-1           = *James J. Hirsch & Associates*
   LINE-2           = *ASHRAE Standard 140 Tests*
   LINE-3           = *Case E130 - Dry, Low PLR, 115, 72*
   ..

RUN-PERIOD-PD
   BEGIN-MONTH      = 1
   BEGIN-DAY        = 1
   BEGIN-YEAR       = 1967
   END-MONTH        = 2
   END-DAY          = 28
   END-YEAR         = 1967
   ..




$ ---------------------------------------------------------
$              Compliance Data
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Site and Building Data
$ ---------------------------------------------------------

"SITE-PARAMETERS 1" = SITE-PARAMETERS 
   LATITUDE         = 25.8
   LONGITUDE        = 80.3
   TIME-ZONE        = 5
   ALTITUDE         = 6
   DAYLIGHT-SAVINGS = NO
   GROUND-T         = ( 75.4, 75.4, 75.4, 75.4, 75.4, 75.4, 75.4, 75.4, 75.4, 
         75.4, 75.4, 75.4 )
   ..

"BUILD-PARAMETERS 1" = BUILD-PARAMETERS
   AZIMUTH          = 0
   GROSS-AREA       = 516.7
   ..



PROJECT-DATA    
   ..


$ ---------------------------------------------------------
$              Materials / Layers / Constructions
$ ---------------------------------------------------------



"LOW-MASS-WALL" = CONSTRUCTION    
   TYPE             = U-VALUE
   ABSORPTANCE      = 0.1
   ROUGHNESS        = 2
   U-VALUE          = 0.00176
   ..


$ ---------------------------------------------------------
$              Glass Type Codes
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Glass Types
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Window Layers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Lamps / Luminaries / Lighting Systems
$ ---------------------------------------------------------





$ ---------------------------------------------------------
$              Day Schedules
$ ---------------------------------------------------------

"ALL-DAY" = DAY-SCHEDULE-PD
   TYPE             = FRACTION
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule   2" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule   3" = DAY-SCHEDULE-PD
   TYPE             = TEMPERATURE
   VALUES           = ( 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 
         68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68 )
   ..
"Day Schedule   4" = DAY-SCHEDULE-PD
   TYPE             = TEMPERATURE
   VALUES           = ( 72, 72, 72, 72, 72, 72, 72, 72, 72, 72, 72, 72, 72, 
         72, 72, 72, 72, 72, 72, 72, 72, 72, 72, 72 )
   ..
"Day Schedule   5" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule   6" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 
         0, 0, 0, 0, 0, 0 )
   ..
"Day Schedule   7" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..

$ ---------------------------------------------------------
$              Week Schedules
$ ---------------------------------------------------------

"ALL-WEEK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "ALL-DAY", "ALL-DAY", "ALL-DAY", "ALL-DAY", "ALL-DAY", 
         "ALL-DAY", "ALL-DAY", "ALL-DAY" )
   ..
"Week Schedule  2" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule   2", "Day Schedule   2", 
         "Day Schedule   2", "Day Schedule   2", "Day Schedule   2", 
         "Day Schedule   2", "Day Schedule   2", "Day Schedule   2" )
   ..
"Week Schedule  3" = WEEK-SCHEDULE-PD
   TYPE             = TEMPERATURE
   DAY-SCHEDULES    = ( "Day Schedule   3", "Day Schedule   3", 
         "Day Schedule   3", "Day Schedule   3", "Day Schedule   3", 
         "Day Schedule   3", "Day Schedule   3", "Day Schedule   3" )
   ..
"Week Schedule  4" = WEEK-SCHEDULE-PD
   TYPE             = TEMPERATURE
   DAY-SCHEDULES    = ( "Day Schedule   4", "Day Schedule   4", 
         "Day Schedule   4", "Day Schedule   4", "Day Schedule   4", 
         "Day Schedule   4", "Day Schedule   4", "Day Schedule   4" )
   ..
"Week Schedule  5" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule   5", "Day Schedule   5", 
         "Day Schedule   5", "Day Schedule   5", "Day Schedule   5", 
         "Day Schedule   5", "Day Schedule   5", "Day Schedule   5" )
   ..
"Week Schedule  6" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule   6", "Day Schedule   6", 
         "Day Schedule   6", "Day Schedule   6", "Day Schedule   6", 
         "Day Schedule   6", "Day Schedule   6", "Day Schedule   6" )
   ..
"Week Schedule  7" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule   7", "Day Schedule   7", 
         "Day Schedule   7", "Day Schedule   7", "Day Schedule   7", 
         "Day Schedule   7", "Day Schedule   7", "Day Schedule   7" )
   ..

$ ---------------------------------------------------------
$              Annual Schedules
$ ---------------------------------------------------------

"LIT-S" = SCHEDULE-PD
   TYPE             = FRACTION
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "ALL-WEEK" )
   ..
"INF-S" = SCHEDULE-PD
   TYPE             = FRACTION
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "ALL-WEEK" )
   ..
"REP-SCH" = SCHEDULE-PD
   TYPE             = ON/OFF
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  2" )
   ..
"HEAT-S" = SCHEDULE-PD
   TYPE             = TEMPERATURE
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  3" )
   ..
"COOL-S" = SCHEDULE-PD
   TYPE             = TEMPERATURE
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  4" )
   ..
"AHU-S" = SCHEDULE-PD
   TYPE             = ON/OFF
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  5" )
   ..
"ALLOFF" = SCHEDULE-PD
   TYPE             = ON/OFF
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  6" )
   ..
"ALL-MONTH-SCH" = SCHEDULE-PD
   TYPE             = ON/OFF
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  7" )
   ..


$ ---------------------------------------------------------
$              Polygons
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Wall Parameters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Fixed and Building Shades
$ ---------------------------------------------------------




$ ---------------------------------------------------------
$              Misc Cost Related Objects
$ ---------------------------------------------------------





$ *********************************************************
$ **                                                     **
$ **                Performance Curves                   **
$ **                                                     **
$ *********************************************************

"TTP024C-CSCFT" = CURVE-FIT       
   TYPE             = BI-QUADRATIC-T
   INPUT-TYPE       = DATA
   INDEPENDENT-1    = ( 67, 59, 63, 67, 71, 59, 63, 71, 59, 63, 67, 71, 59, 
         63, 67, 71 )
   INDEPENDENT-2    = ( 95, 85, 85, 85, 85, 95, 95, 95, 105, 105, 105, 105, 
         115, 115, 115, 115 )
   DEPENDENT        = ( 1, 1.373, 1.207, 1.028, 0.843, 1.345, 1.18, 0.816, 
         1.318, 1.147, 0.968, 0.784, 1.29, 1.12, 0.94, 0.756 )
   ..
"TTP024C-BF-FT" = CURVE-FIT       
   TYPE             = BI-QUADRATIC-T
   INPUT-TYPE       = DATA
   INDEPENDENT-1    = ( 67, 59, 63, 67, 71, 59, 63, 71, 59, 63, 67, 71, 59, 
         63, 67, 71 )
   INDEPENDENT-2    = ( 95, 85, 85, 85, 85, 95, 95, 95, 105, 105, 105, 105, 
         115, 115, 115, 115 )
   DEPENDENT        = ( 1, 1.143, 0.953, 0.96, 1.076, 1.109, 0.916, 1.326, 
         1.118, 0.911, 1.049, 1.295, 0.991, 0.948, 1.093, 1.252 )
   ..
"TTP024C-BF-FPLR" = CURVE-FIT       
   TYPE             = LINEAR
   INPUT-TYPE       = DATA
   OUTPUT-MIN       = 1
   OUTPUT-MAX       = 1
   INDEPENDENT      = ( 1, 0 )
   DEPENDENT        = ( 1, 1 )
   ..
"TTP024C-CCAPFT" = CURVE-FIT       
   TYPE             = BI-QUADRATIC-T
   INPUT-TYPE       = DATA
   INDEPENDENT-1    = ( 67, 59, 63, 67, 71, 59, 63, 71, 59, 63, 67, 71, 59, 
         63, 67, 71 )
   INDEPENDENT-2    = ( 95, 85, 85, 85, 85, 95, 95, 95, 105, 105, 105, 105, 
         115, 115, 115, 115 )
   DEPENDENT        = ( 1, 0.907, 0.979, 1.057, 1.136, 0.86, 0.928, 1.075, 
         0.814, 0.875, 0.939, 1.007, 0.764, 0.821, 0.882, 0.943 )
   ..
"TTP024C-EIR-FT" = CURVE-FIT       
   TYPE             = BI-QUADRATIC-T
   INPUT-TYPE       = DATA
   INDEPENDENT-1    = ( 67, 59, 63, 67, 71, 59, 63, 71, 59, 63, 67, 71, 59, 
         63, 67, 71 )
   INDEPENDENT-2    = ( 95, 85, 85, 85, 85, 95, 95, 95, 105, 105, 105, 105, 
         115, 115, 115, 115 )
   DEPENDENT        = ( 1, 0.961, 0.913, 0.87, 0.834, 1.107, 1.049, 0.956, 
         1.283, 1.218, 1.158, 1.101, 1.487, 1.403, 1.331, 1.262 )
   ..
"TTP024C-CLOSFPLR" = CURVE-FIT       
   TYPE             = CUBIC
   INPUT-TYPE       = DATA
   OUTPUT-MIN       = 0.75
   OUTPUT-MAX       = 1
   INDEPENDENT      = ( 1, 0, 0.1, 0.2, 0.3, 0.4, 0.5, 0.6, 0.7, 0.8, 0.9 )
   DEPENDENT        = ( 1, 0.771, 0.794, 0.817, 0.84, 0.863, 0.886, 0.908, 
         0.931, 0.954, 0.977 )
   ..

$ *********************************************************
$ **                                                     **
$ **      Floors / Spaces / Walls / Windows / Doors      **
$ **                                                     **
$ *********************************************************

SET-DEFAULT FOR FLOOR           
   SHAPE            = NO-SHAPE
   FLOOR-HEIGHT     = {no_def}
   ..

SET-DEFAULT FOR SPACE           
   SHAPE            = NO-SHAPE
   ..

"DEFAULT-FLOOR" = FLOOR           
   C-DIAGRAM-DATA   = *Detailed UI DiagData*
   ..
"HVBT-SPACE" = SPACE           
   X                = 0
   Y                = 0
   Z                = 0
   AZIMUTH          = 0
   AREA             = 516.7
   VOLUME           = 4577
   FLOOR-WEIGHT     = 30
   ZONE-TYPE        = CONDITIONED
   TEMPERATURE      = ( 72 )
   LIGHTING-SCHEDUL = ( "LIT-S" )
   EQUIP-SCHEDULE   = ( "LIT-S" )
   INF-SCHEDULE     = "INF-S"
   LIGHTING-TYPE    = ( SUS-FLUOR )
   INF-METHOD       = AIR-CHANGE
   INF-FLOW/AREA    = 0
   LIGHTING-KW      = ( 0.27 )
   LIGHT-TO-SPACE   = ( 1 )
   EQUIPMENT-KW     = ( 0 )
   EQUIP-LATENT     = ( 1 )
   EQUIP-SENSIBLE   = ( 0 )
   LIGHT-RAD-FRAC   = ( 0, 0 )
   ..
"N-WALL-EXT" = EXTERIOR-WALL   
   CONSTRUCTION     = "LOW-MASS-WALL"
   GND-REFLECTANCE  = 0.2
   OUTSIDE-EMISS    = 0.9
   INSIDE-SOL-ABS   = 0.6
   X                = 26.25
   Y                = 19.69
   Z                = 0
   HEIGHT           = 8.59
   WIDTH            = 26.25
   AZIMUTH          = 0
   TILT             = 90
   ..
"E-WALL-EXT" = EXTERIOR-WALL   
   LIKE = "N-WALL-EXT"
   Y                = 0
   WIDTH            = 19.69
   AZIMUTH          = 90
   ..
"S-WALL-EXT" = EXTERIOR-WALL   
   LIKE = "N-WALL-EXT"
   X                = 0
   Y                = 0
   AZIMUTH          = 180
   ..
"W-WALL-EXT" = EXTERIOR-WALL   
   LIKE = "N-WALL-EXT"
   X                = 0
   WIDTH            = 19.69
   AZIMUTH          = 270
   ..
"L-ROOF" = EXTERIOR-WALL   
   CONSTRUCTION     = "LOW-MASS-WALL"
   GND-REFLECTANCE  = 0
   OUTSIDE-EMISS    = 0.9
   INSIDE-SOL-ABS   = 0.6
   X                = 0
   Y                = 0
   Z                = 8.59
   HEIGHT           = 19.69
   WIDTH            = 26.25
   AZIMUTH          = 180
   TILT             = 0
   ..
"L-FLOOR" = EXTERIOR-WALL   
   CONSTRUCTION     = "LOW-MASS-WALL"
   GND-REFLECTANCE  = 0
   SKY-FORM-FACTOR  = 0
   GND-FORM-FACTOR  = 0
   OUTSIDE-EMISS    = 0.9
   INSIDE-SOL-ABS   = 0.6
   SOLAR-FRACTION   = 0.648
   X                = 0
   Y                = 19.69
   Z                = 0
   HEIGHT           = 19.69
   WIDTH            = 26.25
   AZIMUTH          = 180
   TILT             = 180
   ..


$ *********************************************************
$ **                                                     **
$ **              Electric & Fuel Meters                 **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Electric Meters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Fuel Meters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Master Meters
$ ---------------------------------------------------------

"MASTER-METERS 1" = MASTER-METERS   
   MSTR-ELEC-METER  = "EM1"
   MSTR-FUEL-METER  = "FM1"
   ..


$ *********************************************************
$ **                                                     **
$ **      HVAC Circulation Loops / Plant Equipment       **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Pumps
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Heat Exchangers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Circulation Loops
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Chillers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Boilers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Domestic Water Heaters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Heat Rejection
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Tower Free Cooling
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Photovoltaic Modules
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Electric Generators
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Thermal Storage
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Ground Loop Heat Exchangers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Compliance DHW (residential dwelling units)
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **            Steam & Chilled Water Meters             **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Steam Meters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Chilled Water Meters
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **               HVAC Systems / Zones                  **
$ **                                                     **
$ *********************************************************

"SYSTEM-1" = SYSTEM          
   TYPE             = RESYS2
   RETURN-AIR-PATH  = DUCT
   MAX-SUPPLY-T     = 105
   HEATING-SCHEDULE = "ALLOFF"
   MIN-SUPPLY-T     = 46
   COOLING-SCHEDULE = "AHU-S"
   SUPPLY-FLOW      = 900
   MIN-OUTSIDE-AIR  = 0
   OA-CONTROL       = FIXED
   FAN-SCHEDULE     = "AHU-S"
   FAN-CONTROL      = CYCLING
   SUPPLY-DELTA-T   = 0.789
   SUPPLY-KW/FLOW   = 0.000256
   MOTOR-PLACEMENT  = IN-AIRFLOW
   FAN-PLACEMENT    = DRAW-THROUGH
   INDOOR-FAN-MODE  = INTERMITTENT
   COOLING-CAPACITY = 27900
   COOL-CAP-FT      = "TTP024C-CCAPFT"
   COOLING-EIR      = 0.227
   COOL-EIR-FT      = "TTP024C-EIR-FT"
   COOL-SH-CAP      = 21700
   COOL-SH-FT       = "TTP024C-CSCFT"
   COIL-BF          = 0.049
   COIL-BF-FT       = "TTP024C-BF-FT"
   MIN-UNLOAD-RATIO = 1
   MIN-HGB-RATIO    = 1
   CRANKCASE-HEAT   = 0
   OUTSIDE-FAN-ELEC = 0.003871
   OUTSIDE-FAN-T    = 45
   OUTSIDE-FAN-MODE = INTERMITTENT
   COMPRESSOR-TYPE  = SINGLE-SPEED
   FURNACE-AUX      = 0
   COOL-FT-MIN      = 65
   CRANKCASE-MAX-T  = 50
   CONDENSER-TYPE   = AIR-COOLED
   COIL-BF-FPLR     = "TTP024C-BF-FPLR"
   COOL-CLOSS-FPLR  = "TTP024C-CLOSFPLR"
   COOL-CLOSS-MIN   = 0
   CONTROL-ZONE     = "HVBT-ZONE"
   ..
"HVBT-ZONE" = ZONE            
   TYPE             = CONDITIONED
   OUTSIDE-AIR-FLOW = 0
   ASSIGNED-FLOW    = 900
   DESIGN-HEAT-T    = 70
   HEAT-TEMP-SCH    = "HEAT-S"
   DESIGN-COOL-T    = 75
   COOL-TEMP-SCH    = "COOL-S"
   THERMOSTAT-TYPE  = TWO-POSITION
   THROTTLING-RANGE = 0.1
   SPACE            = "HVBT-SPACE"
   ..


$ *********************************************************
$ **                                                     **
$ **                Metering & Misc HVAC                 **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Equipment Controls
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Load Management
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **                    Utility Rates                    **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Ratchets
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Block Charges
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Utility Rates
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **                 Output Reporting                    **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Loads Non-Hourly Reporting
$ ---------------------------------------------------------

LOADS-REPORT    
   VERIFICATION     = ( LV-N )
   SUMMARY          = ( LS-D )
   ..


$ ---------------------------------------------------------
$              Systems Non-Hourly Reporting
$ ---------------------------------------------------------

SYSTEMS-REPORT  
   SUMMARY          = ( SS-A )
   REPORT-FREQUENCY = HOURLY
   ..


$ ---------------------------------------------------------
$              Plant Non-Hourly Reporting
$ ---------------------------------------------------------

PLANT-REPORT    
   SUMMARY          = ( PS-E, PS-F )
   ..


$ ---------------------------------------------------------
$              Economics Non-Hourly Reporting
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Hourly Reporting
$ ---------------------------------------------------------

"BLDC1" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 19 )
   ..
"BLDC2" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 20 )
   ..
"BLDC3" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 21 )
   ..
"BLDC4" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 22 )
   ..
"BLDC9" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 27 )
   ..
"BLDC10" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 28 )
   ..
"BLDC12" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 30 )
   ..
"BLDC16" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 34 )
   ..
"SKWQC" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 47 )
   ..
"EIR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 68 )
   ..
"EIRM1" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 66 )
   ..
"EIRM2" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 67 )
   ..
"SFKW" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 49 )
   ..
"OFKW" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 69 )
   ..
"CFM" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 17 )
   ..
"CINF" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 22 )
   ..
"QCT" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 70 )
   ..
"QCM1" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 63 )
   ..
"QCS" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 71 )
   ..
"QCM2" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 64 )
   ..
"QC" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 6 )
   ..
"QNOW" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 8 )
   ..
"QCLAT" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 48 )
   ..
"QS" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 1 )
   ..
"QL" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 2 )
   ..
"TNOW" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 6 )
   ..
"TAVE" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 31 )
   ..
"WR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 35 )
   ..
"DBT" = REPORT-BLOCK    
   VARIABLE-TYPE    = GLOBAL
   VARIABLE-LIST    = ( 4 )
   ..
"TCZ" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 18 )
   ..
"WCOIL" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 37 )
   ..
"WW" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 38 )
   ..
"HUMRAT" = REPORT-BLOCK    
   VARIABLE-TYPE    = GLOBAL
   VARIABLE-LIST    = ( 10 )
   ..
"PLRC" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 61 )
   ..
"PLRCC" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 210 )
   ..
"CLPLR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 211 )
   ..
"CLOSFPLR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 191 )
   ..
"TSURF" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 54 )
   ..
"CBF" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 56 )
   ..
"CBF1" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 57 )
   ..
"BFFPLR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 175 )
   ..
"CBF2" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 58 )
   ..
"TC" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 2 )
   ..
"TCMIN" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 13 )
   ..
"QCZ" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 8 )
   ..
"RCFM" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 20 )
   ..
"ECFM" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 21 )
   ..
"SKW" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 32 )
   ..
"FANKW" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 33 )
   ..
"PCH" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 75 )
   ..
"QHSUP" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 81 )
   ..
"ZQC" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 33 )
   ..
"CFMZ" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 14 )
   ..
"DTON" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 100 )
   ..
"QCLOAD" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 156 )
   ..
"QCFAN" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 164 )
   ..
"WBR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 92 )
   ..
"QCRUN" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 155 )
   ..

"LOADS-RPT" = HOURLY-REPORT   
   REPORT-SCHEDULE  = "REP-SCH"
   REPORT-BLOCK     = ( "BLDC1", "BLDC2", "BLDC3", "BLDC4", "BLDC9", "BLDC10", 
         "BLDC12", "BLDC16" )
   ..
"R#1-CLG-ELEC" = HOURLY-REPORT   
   REPORT-SCHEDULE  = "ALL-MONTH-SCH"
   REPORT-BLOCK     = ( "SKWQC", "SFKW", "QNOW", "QCLAT" )
   ..


$ ---------------------------------------------------------
$              THE END
$ ---------------------------------------------------------

END ..
COMPUTE ..
STOP ..
